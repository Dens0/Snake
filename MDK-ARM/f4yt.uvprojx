# Keil uVision project f4yt.uvprojx, settings and files
target f4yt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: f4yt
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.12.0\Drivers\BSP\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.12.0/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_accelerometer.c stm32f4_discovery_audio.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.12.0/Drivers/BSP/Components/lis3dsh/: lis3dsh.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.12.0/Drivers/BSP/Components/lis302dl/: lis302dl.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.12.0/Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
    $TC_ROOT$/PACK/Keil/STM32F4xx_DFP/2.12.0/Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c
software components: CMSIS:CORE 4.3.0
